# Keil uVision project sample.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: MCP3204 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s spi.c mcp3204.c delay.c main_MCP3204_LEDs.c main_MCP3204_LCD.c lcd8.c mcp3204_arduino_api.c gpio.c main_mcp3204_arduino_api.c arduino_api.c lcd_arduino_api.c main_mcp3204_lcd_test.c lm35.c main_mcp3204_lm35_lcd_test.c spi_arduino_api.c External_Interrupts.c main_eint0_interrupt.c
