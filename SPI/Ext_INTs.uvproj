# Keil uVision project Ext_INTs.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2114 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Ext_INTs
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: Ext_INTs.sct
  group Source Group 1
    ./: Startup.s External_Interrupts.c eint0_interrupt.c main_eint0_interrupt.c arduino_api.c lcd_arduino_api.c gpio.c delay.c
